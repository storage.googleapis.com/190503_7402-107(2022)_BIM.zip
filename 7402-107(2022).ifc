Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2022-01-19T22:48:14
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.3.3.18 - Alternate UI 18.3.3.18
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 19 22:48:14 2022 * Host: Avocado-PC * Database: D:\Jocuri\TEMP\{2D2DF769-A237-4D43-B74C-BBEFC3ED250A}\ifc * Database version: 5507 * Database creation date: Wed Jan 19 22:48:12 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 19 22:48:12 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 19 22:48:12 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 7402-107 Shower system, 7402-107(2022):7402-107 Shower system:479862
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Constraints - ShowerDefaultElevation: 900 mm
Type - Dimensions - NominalDepth: 545.692 mm; NominalHeight: 1162.51 mm; NominalWidth: 291.051 mm
Type - General - Author: BIMStone; BIMObjectName: 7402-107(2022); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: Thermostatic shower faucet with spout; Revision: n/a; Uniclass2: Pr_40_30_96_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 18/01/2022
Type - Green Building Properties - Approval KIWA SE Type Approval: 1664; Backflow Prevention EN1717: EB; EAN Number: 6414150100321; EN Standard: EN 1111, EN 1112, EN 1113; Sales Package dimensions (LxWxH): 1154 x 383 x 98; Sales Package gross weight: 4.75 kg; Sales Package package weight: 1.2143 kg; URL KIWA SE Type Approval: http://static.oras.com/KIWASETypeApproval/7402-107/original; URL REACH: http://static.oras.com/doc/reach
Type - Identity Data - Catalog Drawing URL: http://static.oras.com/catdrw/7402-107; Dimension Drawing URL: http://static.oras.com/dimdrw/7402-107; FDV Document URL: http://www.oras.com/datasheet/7402-107/en/fdv; Group: Shower system; Installation and Maintenance Guide URL: http://static.oras.com/manual/7402-107; Item Type: Sales item; Manufacturer: Oras; Market: International;Finland;Norway;Sweden;Denmark;Poland;Russia;Estonia;Lithuania;Latvia; Mobile Product Information URL: http://mpi.oras.com/7402-107; Model: 7402-107 Shower system; Name_en: 7402-107 Shower system; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 7402-107; Product Family: Oras Nova Eco; Product Image URL: http://static.oras.com/image/7402-107; Product URL: http://static.oras.com/7402-107; Spare-Part Information URL: http://static.oras.com/sp/7402-107; Technical DataSheet URL: http://www.oras.com/datasheet/7402-107/en; Type Name: 7402-107 Shower system; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: Flexible length / can be shortened; Connection: Direct connection; Connection Size: G3/4; Diverter: Turn operated diverter;Integrated into flow control handle; Excluded Items: Without couplings; Flow Rate At 300kPa With Flow Controller: 0.0441433 m3/s; Hand Shower Size: Ø 95 mm; Installation Type: Wall mounted; Installation Width: CC150± 3 mm; Lever Handle: Temperature control handle;Flow control handle; Max. Hot Water Supply: 65 kg/K/s3; Mechanical Parts: Ceramic head part for flow control;Thermostatic cartridge for automatic temperature control;Non-return valve(s);Litter filter(s); Noise Class: I (ISO 3822) Oras lab.; Over Head Shower Size: Ø 200 mm; Shower Parts: Hand shower;Shower rail;Overhead shower;Adjustable shower rail bracket;Variable fixing points;Rotatable ball joint connection;Anti limescale technology (easy to clean);Twist guard for shower hose; Shower Spray: Intense; Shower Spray Number: 1 shower spray; Surface treatment: Chrome; Temperature: Thermostatic safety stop at 38°C;THERMO COOL; Temperature Adjustments: Safety stop against scalding at 38°C;The housing of the fittings conducts minimal heat; Working Pressure: 100 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 7402-107(2022); Features: Thermostatic;Green Building; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 7402-107; Name: 7402-107 Shower system; ReplacementCost: n/a; Shape: Sculptured; Size: 290x545x1165 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 7402-107; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 7402-107 Shower system
Constraints - Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 1.13518 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 20 mm; InletDistance: 150 mm; OutletAngle: 0 deg; Volume: 0.184666 m3
Identity Data - Mark: 2
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 7402-107(2022): 7402-107 Shower system; Family and Type: 7402-107(2022): 7402-107 Shower system; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 7402-107(2022): 7402-107 Shower system; Type Id: 7402-107(2022): 7402-107 Shower system; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
